Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-10-19T17:51:39+02:00
Written by: IfcOpenShell 0.9.0.post1
Made in: IfcOpenShell 0.9.0.post1
Authorization: Nobody

# IfcFurniture: Pflanzkasten, Pflanzkasten Linth 1500 × 500 × 450 mm
In: Standort
Pset_ManufacturerTypeInformation - Manufacturer: Obersee Holzwerke (Karawan Holz GmbH); ModelLabel: Pflanzkasten Linth 1500 × 500 × 450 mm; ModelReference: LINTH-1500-500-450
OH_Abmessungen - Laenge_mm: 1500; Breite_mm: 500; Hoehe_mm: 450; Gewicht_leer_ca_kg: 59; Material: Lärche, Stahl S235 feuerverzinkt + pulverbeschichtet schwarz matt
